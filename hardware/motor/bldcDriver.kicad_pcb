# Repository podwan/balancer

## KiCad design hardware/motor/bldcDriver.kicad_pcb

Parts:
C1, C2: 22u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3, C10, C17, C18, C19, C20, C21, C22, C24, C38, C40, C45, C46, C47, C48, C50, C52, C53, C54: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4, C13: 10n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5, C6, C7: 47u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C8: 470n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9, C39, C43, C44: 4.7u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C11, C27, C41, C42: 2.2n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C23: 2.2u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C67, C68: 12p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: 1N5712UR; SMA_L4.3-W2.6-LS5.0-RD
D8: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D12: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
FB1, FB4: FerriteBead; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
FB2: FerriteBead; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
FB3: FerriteBead; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
J1: Conn_01x02; AMASS_XT30U-M_1x02_P5.0mm_Vertical
J2: Conn_01x06; CONN-SMD_6P-P1.00_MEGASTAR_ZX-SH1.0-6PWT
L1: 10u; L_Taiyo-Yuden_NR-40xx_HandSoldering
P1: FPC_0.5MM_4P_Vertical_mounting_type_H2.0mm; FPC-SMD_4P-L7.5-W2.0-P0.50
R1, R31, R33, R34, R36, R45, R47, R48, R51: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 5.9k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R20, R21, R30, R32, R38, R39, R41, R42, R43, R44, R46, R49: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R35, R37, R50, R52: 100R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RV1: R_Potentiometer; RES-ADJ-TH_3362P
SW1, SW2: SW_Push; SW-SMD_L4.0-W2.9-LS5.0
TP7, TP8, TP10, TP17, TP18, TP19, TP20, TP21, TP22, TP23, TP24, TP25, TP29, TP30, TP31, TP32, TP33, TP34, TP35, TP40: TestPoint; TestPoint_Pad_D1.0mm
U3: TPS5430DDA; TI_SO-PowerPAD-8_ThermalVias
U4, U10: HC-FPC-0.5-6P-CSH20; FPC-SMD_6P-P0.50_HC-FPC-0.5-6P-CSH20
U5: STM32G431CBUx; QFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm
U6, U7, U8: TLV9062xD; SOIC-8_3.9x4.9mm_P1.27mm
U9: MPU6500; QFN24_3X3X0P9_IVS-L
Y1: 25MHz; Crystal_SMD_SeikoEpson_FA238-4Pin_3.2x2.5mm

Connections:
+3V3: C5.2, C6.2, C7.2, C18.1, C19.1, C20.1, C50.2, C54.2, D12.1 (VDD), FB1.2, FB3.2, FB4.1, J2.6, L1.2, P1.1, R1.1, R3.1, RV1.1, TP20.1, U4.5, U5.1 (VBAT), U5.23 (VDD), U5.35 (VDD), U5.48 (VDD), U10.5
+BATT: C1.2, C2.2, C3.2, J1.2, U3.7 (VIN); also elsewhere on the board
/1CS1+: R21.2; also elsewhere on the board
/1CS1-: R32.2; also elsewhere on the board
/1CS2+: R43.2; also elsewhere on the board
/1CS2-: R46.2; also elsewhere on the board
/2CS1+: R20.2; also elsewhere on the board
/2CS1-: R30.2; also elsewhere on the board
/2CS2+: R42.2; also elsewhere on the board
/2CS2-: R44.2; also elsewhere on the board
/ADC1_IN2: C38.1, RV1.2, U5.9 (PA1)
/ADC1_IN11: C41.2, R50.2, TP19.1
/ADC1_IN12_COMP1_INP: C27.2, R37.2, TP17.1, U5.18 (PB1)
/ADC1_IN15_COMP4_INP: C11.2, R35.2, TP18.1, U5.17 (PB0)
/ADC2_IN15: C42.2, R52.2, TP8.1, U5.28 (PB15)
/INA1+: R38.1, R39.2, U8.5 (+)
/INA2+: R41.1, R49.2, TP40.1, U8.3 (+)
/KEY: C52.1, SW2.1, U5.3 (PC14); also elsewhere on the board
/NSS1: TP32.1, U5.41 (PB3), U10.1
/NSS2: TP33.1, U4.1, U5.16 (PC4)
/OP_VCC: C9.2, C10.2, C39.2, C40.2, C45.2, C46.2, C47.2, FB3.1, R38.2, R41.2, U6.8 (V+), U7.8 (V+), U8.8 (V+)
/RESET: C21.1, SW1.1, U5.7 (PG10)
/RGB: D12.4 (DIN), U5.8 (PA0)
/SPI1_CS: U5.12 (PA4), U9.22 (nCS)
/SPI1_MISO: TP24.1, U5.14 (PA6), U9.9 (SDO/AD0)
/SPI1_MOSI: TP25.1, U5.15 (PA7), U9.24 (SDA/SDI)
/SPI1_SCK: TP23.1, U5.13 (PA5), U9.23 (SCL/SCLK)
/SPI3_MISO: TP30.1, U4.3, U5.40 (PC11), U10.3
/SPI3_MOSI: TP29.1, U4.2, U5.43 (PB5), U10.2
/SPI3_SCK: TP31.1, U4.4, U5.39 (PC10), U10.4
/SWCLK: J2.1, U5.37 (PA14)
/SWDIO: J2.2, U5.36 (PA13)
/TIM1_CH1: U5.30 (PA8); also elsewhere on the board
/TIM1_CH2: U5.31 (PA9); also elsewhere on the board
/TIM1_CH3: U5.32 (PA10); also elsewhere on the board
/TIM8_CH1: U5.44 (PB6); also elsewhere on the board
/TIM8_CH2: U5.46 (PB8); also elsewhere on the board
/TIM8_CH3: U5.47 (PB9); also elsewhere on the board
/USART2_RX: P1.4, TP34.1, U5.11 (PA3)
/USART2_TX: P1.2, TP35.1, U5.10 (PA2)
/USART3_RX: J2.3, U5.24 (PB11)
/USART3_TX: J2.4, U5.22 (PB10)
/VREF_OP1: C43.2, C48.2, R33.2, R47.2, U8.6 (-), U8.7
/VREF_OP2: C44.2, C53.2, R31.2, R45.2, U8.1, U8.2 (-)
/YI: C67.1, U5.5 (PF0), Y1.1
/YO: C68.1, U5.6 (PF1), Y1.3
GNDD: C8.2, C9.1, C10.1, C11.1, C13.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C27.1, C38.2, C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, C48.1, C52.2, C53.1, C54.1, C67.2, C68.2, D12.3 (VSS), FB2.2, J2.5, P1.3, R39.1, R49.1, RV1.3, SW1.2, SW2.2, TP22.1, U4.6, U5.49 (VSS), U6.4 (V-), U7.4 (V-), U8.4 (V-), U9.11 (FSYNC), U9.18 (GND), U9.20 (RESV), U10.6, Y1.2, Y1.4; also elsewhere on the board
GNDPWR: C1.1, C2.1, C3.1, C5.1, C6.1, C7.1, C50.1, D1.2 (A), D8.1 (K), FB2.1, J1.1, R2.2, TP21.1, U3.6 (GND), U3.9 (GNDPAD); also elsewhere on the board
unnamed: C4.2, D1.1 (K), L1.1, U3.8 (PH)
unnamed: D8.2 (A), R3.2
unnamed: R34.2, R35.1, U6.1
unnamed: R36.2, R37.1, U7.1
unnamed: R48.2, R50.1, U6.7
unnamed: R51.2, R52.1, U7.7
unnamed: C4.1, U3.1 (BOOT)
unnamed: R1.2, R2.1, U3.4 (VSENSE)
unnamed: TP10.1, U5.38 (PA15)
unnamed: TP7.1, U5.25 (PB12)
unnamed: R30.1, R31.1, U6.3 (+)
unnamed: R20.1, R34.1, U6.2 (-)
unnamed: R44.1, R45.1, U6.5 (+)
unnamed: R42.1, R48.1, U6.6 (-)
unnamed: R32.1, R33.1, U7.3 (+)
unnamed: R21.1, R36.1, U7.2 (-)
unnamed: R46.1, R47.1, U7.5 (+)
unnamed: R43.1, R51.1, U7.6 (-)
unnamed: C22.1, U9.10 (REGOUT)
unnamed: C13.1, C23.1, C24.1, FB1.1, U9.8 (VDDIO), U9.13 (VDD)
VDDA: C8.1, C17.1, FB4.2, U5.20 (VREF+), U5.21 (VDDA)

Notes on the sheet:
current sense

Parts:
C12, C14, C33, C34, C49, C51: 47u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C15, C32: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C16, C25, C26, C29, C30, C31: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C28, C35, C36, C37: 1n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
CN1, CN2: MR30PW-F; CONN-SMD_3P-P1.00_BX-SH1.0-3PWT
D2, D3, D4, D7, D10, D11: FR107; SOD-123FL_L2.7-W1.8-LS3.8-RD
D5, D6, D9, D16, D17, D18, D19, D20, D21, D22, D23, D24: 1N4148W; D_SOD-123
Q1, Q2, Q7, Q8, Q9, Q10, Q11, Q12, Q13, Q14, Q15, Q16: EMB09N03V; POWERTDFN-8_L3.1-W3.1-P0.65-LS3.3-BL
R4, R5, R6, R7, R8, R13, R14, R15, R16, R17, R18, R19: 10R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9, R10, R11, R12: 10mR; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R22, R23, R24, R25, R26, R27, R28, R29: 100R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R40, R54, R55, R56, R57, R58: 3k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TP1, TP2, TP3, TP4, TP5, TP6: TestPoint; TestPoint_Pad_1.0x1.0mm
TP9, TP11, TP12, TP13, TP14, TP15, TP16, TP26, TP27, TP28: TestPoint; TestPoint_Pad_D1.0mm
U1, U2: EG2133; eg2133

Connections:
+BATT: C12.2, C14.2, C15.1, C32.1, C33.2, C34.2, C49.2, C51.2, D2.2 (A), D3.2 (A), D4.2 (A), D7.2 (A), D10.2 (A), D11.2 (A), Q2.5 (D), Q2.6 (D), Q2.7 (D), Q2.8 (D), Q7.5 (D), Q7.6 (D), Q7.7 (D), Q7.8 (D), Q9.5 (D), Q9.6 (D), Q9.7 (D), Q9.8 (D), Q11.5 (D), Q11.6 (D), Q11.7 (D), Q11.8 (D), Q13.5 (D), Q13.6 (D), Q13.7 (D), Q13.8 (D), Q15.5 (D), Q15.6 (D), Q15.7 (D), Q15.8 (D), U1.7 (VCC), U2.7 (VCC); also elsewhere on the board
/1CS1+: C28.2, R22.2; also elsewhere on the board
/1CS1-: C28.1, R23.2; also elsewhere on the board
/1CS2+: C35.2, R24.2; also elsewhere on the board
/1CS2-: C35.1, R25.2; also elsewhere on the board
/2CS1+: C36.2, R26.2; also elsewhere on the board
/2CS1-: C36.1, R27.2; also elsewhere on the board
/2CS2+: C37.2, R28.2; also elsewhere on the board
/2CS2-: C37.1, R29.2; also elsewhere on the board
/TIM1_CH1: R58.1, TP13.1, U1.3 (HIN3), U1.6 (LIN3#); also elsewhere on the board
/TIM1_CH2: R57.1, TP12.1, U1.2 (HIN2), U1.5 (LIN2#); also elsewhere on the board
/TIM1_CH3: R56.1, TP11.1, U1.1 (HIN1), U1.4 (LIN1#); also elsewhere on the board
/TIM8_CH1: R55.1, TP16.1, U2.3 (HIN3), U2.6 (LIN3#); also elsewhere on the board
/TIM8_CH2: R54.1, TP15.1, U2.2 (HIN2), U2.5 (LIN2#); also elsewhere on the board
/TIM8_CH3: R40.1, TP14.1, U2.1 (HIN1), U2.4 (LIN1#); also elsewhere on the board
/inverter/1HO1: D23.1 (K), R6.1, U2.19 (HO1)
/inverter/1HO2: D9.1 (K), R4.1, U2.16 (HO2)
/inverter/1HO3: D5.1 (K), R8.1, U2.13 (HO3)
/inverter/1LO1: D24.1 (K), R19.1, U2.11 (LO1)
/inverter/1LO2: D22.1 (K), R5.1, U2.10 (LO2)
/inverter/1LO3: D6.1 (K), R7.1, U2.9 (LO3)
/inverter/1VS1: C29.2, CN1.1, Q15.1 (S), Q15.2 (S), Q15.3 (S), Q16.5 (D), Q16.6 (D), Q16.7 (D), Q16.8 (D), TP3.1, U2.18 (VS1)
/inverter/1VS2: C30.2, CN1.2, Q2.1 (S), Q2.2 (S), Q2.3 (S), Q14.5 (D), Q14.6 (D), Q14.7 (D), Q14.8 (D), TP2.1, U2.15 (VS2)
/inverter/1VS3: C31.2, CN1.3, Q1.5 (D), Q1.6 (D), Q1.7 (D), Q1.8 (D), Q13.1 (S), Q13.2 (S), Q13.3 (S), TP1.1, U2.12 (VS3)
/inverter/2HO1: D16.1 (K), R13.1, U1.19 (HO1)
/inverter/2HO2: D18.1 (K), R15.1, U1.16 (HO2)
/inverter/2HO3: D20.1 (K), R17.1, U1.13 (HO3)
/inverter/2LO1: D17.1 (K), R14.1, U1.11 (LO1)
/inverter/2LO2: D19.1 (K), R16.1, U1.10 (LO2)
/inverter/2LO3: D21.1 (K), R18.1, U1.9 (LO3)
/inverter/2VS1: C16.2, CN2.1, Q7.1 (S), Q7.2 (S), Q7.3 (S), Q8.5 (D), Q8.6 (D), Q8.7 (D), Q8.8 (D), TP6.1, U1.18 (VS1)
/inverter/2VS2: C25.2, CN2.2, Q9.1 (S), Q9.2 (S), Q9.3 (S), Q10.5 (D), Q10.6 (D), Q10.7 (D), Q10.8 (D), TP5.1, U1.15 (VS2)
/inverter/2VS3: C26.2, CN2.3, Q11.1 (S), Q11.2 (S), Q11.3 (S), Q12.5 (D), Q12.6 (D), Q12.7 (D), Q12.8 (D), TP4.1, U1.12 (VS3)
GNDD: R40.2, R54.2, R55.2, R56.2, R57.2, R58.2; also elsewhere on the board
GNDPWR: C12.1, C14.1, C15.2, C32.2, C33.1, C34.1, C49.1, C51.1, Q10.1 (S), Q10.2 (S), Q10.3 (S), Q14.1 (S), Q14.2 (S), Q14.3 (S), R9.1, R10.1, R11.1, R12.1, R23.1, R25.1, R27.1, R29.1, U1.8 (GND), U2.8 (GND); also elsewhere on the board
unnamed: C16.1, D2.1 (K), U1.20 (VB1)
unnamed: C25.1, D3.1 (K), U1.17 (VB2)
unnamed: C26.1, D4.1 (K), U1.14 (VB3)
unnamed: D5.2 (A), Q13.4 (G), R8.2
unnamed: D6.2 (A), Q1.4 (G), R7.2
unnamed: C29.1, D7.1 (K), U2.20 (VB1)
unnamed: D9.2 (A), Q2.4 (G), R4.2
unnamed: C30.1, D10.1 (K), U2.17 (VB2)
unnamed: C31.1, D11.1 (K), U2.14 (VB3)
unnamed: D16.2 (A), Q7.4 (G), R13.2
unnamed: D17.2 (A), Q8.4 (G), R14.2
unnamed: D18.2 (A), Q9.4 (G), R15.2
unnamed: D19.2 (A), Q10.4 (G), R16.2
unnamed: D20.2 (A), Q11.4 (G), R17.2
unnamed: D21.2 (A), Q12.4 (G), R18.2
unnamed: D22.2 (A), Q14.4 (G), R5.2
unnamed: D23.2 (A), Q15.4 (G), R6.2
unnamed: D24.2 (A), Q16.4 (G), R19.2
unnamed: Q1.1 (S), Q1.2 (S), Q1.3 (S), R9.2, R22.1, TP28.1
unnamed: Q8.1 (S), Q8.2 (S), Q8.3 (S), R11.2, R26.1, TP9.1
unnamed: Q12.1 (S), Q12.2 (S), Q12.3 (S), R12.2, R28.1, TP26.1
unnamed: Q16.1 (S), Q16.2 (S), Q16.3 (S), R10.2, R24.1, TP27.1

Board: 4 copper layers, 89.8 x 41.5 mm, 207 parts (159 on the bottom side), 109 nets.

Other parts of the board:
TP38: TestPoint; TestPoint_Pad_D1.0mm

Their connections:
/KEY: TP38.1; also elsewhere on the board

## KiCad design hardware/rfBat/bat_rf.kicad_pcb

Parts:
BT1: doubleBatCell; BAT-SMD_BH-18650-B1BA007
C1, C4: 2.2u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C5, C6, C7, C11, C13, C14, C16, C17, C18, C27, C30, C31, C32, C33, C34, C35, C36, C37: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C8: 10u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9, C15: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C10, C26: 22u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C12, C28, C29, C40: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D5, D7: 1N4148W; D_SOD-123
D2: RED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D3: G_LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D4: Y_LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D6: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D13: B_LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
FB1: FerriteBead_Small; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2_Pad
J1: USB_C_Receptacle_PowerOnly_6P; USB-C-SMD_HX-TYPE-C-6PIN
J2, J5: Conn_01x01_Pin; TestPoint_Pad_D4.0mm
J3: Conn_01x06; CONN-SMD_6P-P1.00_XYECONN_XY-SH1.0-6A61
J4: Conn_01x04
L1: 10uH; L_Chilisin_BMRA00040420
L2: 2.2uH; L_Taiyo-Yuden_NR-40xx_HandSoldering
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12: XL-4020RGBC-WS2812B; LED-SMD_4P-L4.0-W1.7_M4020-03003-RGB-862-001
P1: FPC_0.5MM_4P_Vertical_mounting_type_H2.0mm; FPC-SMD_4P-L7.5-W2.0-P0.50
Q1: IRFH7440TRPBF; DFN-8_L5.8-W4.9-P1.27-LS6.0-BL-1
Q5: AllPower__AP2300; SOT-23
R1: 0.5R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 5k1; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R5, R13, R15: 3k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R7, R8, R12, R21: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6, R19: 100R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9: 7.5m; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10: 3m; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11: 22k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14, R16, R20: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R17: 500R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R18: 51k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R22: 160k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R23: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: 3*4*2.5MM_贴片4脚; SW-SMD_4P-L4.2-W3.3-P2.15-LS5.1
SW3: TS-1199A-B-B; SW-SMD_L4.0-W2.9-LS5.0
TP1, TP2, TP3, TP4, TP5, TP9: TestPoint; TestPoint_Pad_D1.0mm
U1: ESP32-C3-WROOM-02-N4; BULETM-SMD_18P-L20.0-W18.0-P1.50_ESP32-C3-WROOM
U2: IP2325_5M_WHJC; ESOP-8_L4.9-W3.9-P1.27-LS6.0-BL-EP3.1
U3: MT2492; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL
U4: SS8050_C7420370; SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR
U5: MLT-8530-5V; BUZ-SMD_4P-L8.5-W8.5-TL
U7: XC6220B331MR; SOT-23-5

Connections:
+3V3: C12.1, C13.1, C15.1, J3.1, P1.4, R4.2, R12.2, R16.1, TP2.1, U1.1 (3V3), U7.5 (VOUT)
+5V: C4.1, C5.2, C6.2, C7.1, C8.1, C9.1, C11.2, C14.2, C17.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, D5.1 (K), L1.2, LED1.3 (VDD), LED2.3 (VDD), LED3.3 (VDD), LED4.3 (VDD), LED5.3 (VDD), LED6.3 (VDD), LED7.3 (VDD), LED8.3 (VDD), LED9.3 (VDD), LED10.3 (VDD), LED11.3 (VDD), LED12.3 (VDD), R22.2, U5.1 (+), U7.1 (VIN), U7.3 (CE); also elsewhere on the board
+BATT: BT1.1 (+), C40.1, Q1.1 (S), Q1.2 (S), Q1.3 (S), R8.2, R9.2, U2.2 (VOUT); also elsewhere on the board
/BAT_FB: R14.1, TP5.1, U1.15 (IO3)
/BEEP: R6.1, U1.17 (IO1)
/BLUE: R13.1, U1.10 (IO10)
/EN: C16.1, J3.3, R12.1, SW3.2, U1.2 (EN)
/ESP_RX: P1.3, TP3.1, U1.13 (IO18)
/ESP_TX: P1.1, TP4.1, U1.14 (IO19)
/GREEN: R5.1, U1.3 (IO4)
/IO9: J3.2, U1.8 (IO9)
/K1: D7.2 (A), R19.1, U4.3 (C)
/KEY: D1.2 (A), U1.6 (IO7)
/POWER_EN: R20.1, U1.5 (IO6)
/RGB: LED7.4 (DI), U1.18 (IO0)
/RXD: J3.5, U1.11 (RXD)
/TXD: J3.4, U1.12 (TXD)
/YELLOW: R15.1, U1.16 (IO2)
GNDD: C1.2, C2.2, C3.2, C4.2, C7.2, C8.2, C9.2, C12.2, C13.2, C15.2, C16.2, C37.2, D6.1 (K), FB1.2, J3.6, P1.2, R10.1, R11.2, SW3.1, TP1.1, U1.9 (GND), U1.19 (EP), U3.2 (GND), U7.2 (GND)
GNDPWR: BT1.4 (-), C5.1, C6.1, C10.2, C11.1, C14.1, C17.1, C26.2, C28.2, C29.2, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C40.2, D2.1 (K), D3.1 (K), D4.1 (K), D13.1 (K), FB1.1, J1.A12 (GND), J1.B12 (GND), J1.S1 (SHIELD), J5.1, LED1.1 (VSS), LED2.1 (VSS), LED3.1 (VSS), LED4.1 (VSS), LED5.1 (VSS), LED6.1 (VSS), LED7.1 (VSS), LED8.1 (VSS), LED9.1 (VSS), LED10.1 (VSS), LED11.1 (VSS), LED12.1 (VSS), R2.1, R7.1, R17.1, R18.1, R21.2, SW1.4, TP9.1, U2.9 (GND), U4.2 (E)
unnamed: BT1.2 (-), BT1.3 (+)
unnamed: C28.1, J1.A9 (VBUS), J1.B9 (VBUS), L2.1, R1.1, R2.2
unnamed: C37.1, R9.1, R10.2, R14.2
unnamed: D1.1 (K), D7.1 (K), SW1.1
unnamed: D2.2 (A), R3.1
unnamed: D3.2 (A), R5.2
unnamed: D4.2 (A), R15.2
unnamed: D5.2 (A), Q5.3 (D), U5.2 (-)
unnamed: D6.2 (A), R16.2
unnamed: D13.2 (A), R13.2
unnamed: LED1.4 (DI), LED2.2 (DO)
unnamed: LED1.2 (DO), LED10.4 (DI)
unnamed: LED2.4 (DI), LED3.2 (DO)
unnamed: LED3.4 (DI), LED4.2 (DO)
unnamed: LED4.4 (DI), LED5.2 (DO)
unnamed: LED5.4 (DI), LED6.2 (DO)
unnamed: LED6.4 (DI), LED7.2 (DO)
unnamed: LED8.4 (DI), LED9.2 (DO)
unnamed: LED9.4 (DI), LED10.2 (DO)
unnamed: LED11.4 (DI), LED12.2 (DO)
unnamed: LED8.2 (DO), LED12.4 (DI)
unnamed: Q1.4 (G), R8.1, R19.2
unnamed: Q5.1 (G), R6.2, R7.2
unnamed: Q5.2 (S), R17.2
unnamed: R4.1, U1.7 (IO8)
unnamed: C27.1, U2.7 (BST)
unnamed: R3.2, U2.5 (LED)
unnamed: C27.2, L2.2, U2.8 (LX)
unnamed: R18.2, U2.4 (NTC)
unnamed: C29.1, R1.2, U2.6 (VIN)
unnamed: C10.1, C26.1, U2.1 (VSYS)
unnamed: C18.1, U3.1 (BS)
unnamed: R23.1, U3.4 (EN)
unnamed: R11.1, R22.1, U3.3 (FB)
unnamed: C18.2, L1.1, U3.6 (SW)
unnamed: R20.2, R21.1, U4.1 (B)
VCC: C1.1, C2.1, C3.1, J2.1, Q1.5 (D), Q1.6 (D), Q1.7 (D), Q1.8 (D), Q1.9 (D), R23.2, U3.5 (IN)

Notes on the sheet:
充电（两节18650串联，恒压8.4V）
MCU

Board: 2 copper layers, 89.8 x 41.5 mm, 105 parts (95 on the bottom side), 57 nets.

Other parts of the board:
TP7, TP11: TestPoint; TestPoint_Pad_D1.0mm

Their connections:
+5V: TP7.1; also elsewhere on the board
+BATT: TP11.1; also elsewhere on the board
