# Keil uVision project AT32F403A.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.8
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32F403A
  AfterMake: fromelf --bin !L --output "../bin/AT32_Super_Balance.bin"
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HEXT_VALUE=25000000
  c include: ..\AT32F403A_StdPeriph_Driver\inc;..\AT32F403A_StdPeriph_Driver\src;..\cmsis\core_support;..\cmsis\device_support;..\SYSTEM\delay;..\USER;..\UserFile
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ../UserFile/: app.h
    ./: main.c at32f403a_407_clock.c at32f403a_407_int.c
    ../cmsis/device_support/: system_at32f403a_407.c
  group startup
    ../cmsis/device_support/startup/: startup_at32f403a_407.s
  group AT32F403A_StdPeriph_Driver
    ../AT32F403A_StdPeriph_Driver/src/: at32f403a_407_gpio.c at32f403a_407_crm.c at32f403a_407_misc.c at32f403a_407_tmr.c at32f403a_407_spi.c at32f403a_407_usart.c at32f403a_407_dma.c at32f403a_407_flash.c at32f403a_407_adc.c at32f403a_407_can.c at32f403a_407_i2c.c
  group UserFile
    ../UserFile/: led.c usart.c Debug.c timer.c adc.c Encoder.c MPU6500.c AHRS.c key.c Calibration.c app.c Gpio_Config.c WS2812.c W25Q64.c Control.c AT32F403A_FOC_LIB.lib RcData.c delay.c
  group readme
    ../: readme.md
